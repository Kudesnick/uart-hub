# Keil uVision project hub.uvprojx, settings and files
target debug_nucleo_F413ZH (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00180000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: HSE_VALUE=8000000 HSE_BYPASS STM32F413xx
  c include: ..\source\cpp_os;..\source\bsp\bsp_include;..\source\main;..\source\misc;..\source\sett;..\source\rtt
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\source\main\scatter.sct
  link misc: --predefine="-DSTM32F413xx"
  group biz
    ../source/biz/: cdc_test.cpp
  group bsp
    ../source/bsp/: bsp.c bsp_flash.c bsp_cdc.c USART_STM32F4xx.c
  group cpp_os
    ../source/cpp_os/: cpp_list.cpp cpp_os.cpp cpp_tmr.cpp
  group main
    ../source/main/: main.cpp microboot.c
  group rtt
    ../source/rtt/: RTT_IO.c SEGGER_RTT.c
  group sett
    ../source/sett/: sett_def.cpp sett_work.cpp
target debug_custom_F413VG (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: HSE_VALUE=16000000 HSE_ON STM32F413xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\source\main\scatter.sct
  link misc: --predefine="-DSTM32F413xx"
software components: CMSIS Driver:USART:Custom 2.3.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, USB:CORE 6.13.7, USB:Device 6.13.7, USB:Device:CDC 6.13.7, CMSIS Driver:USB Device:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:CRC 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:EXTI 1.7.6, Device:STM32Cube HAL:Flash 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:RTC 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
